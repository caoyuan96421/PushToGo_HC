# Keil uVision project application.uvproj, settings and files
target Internal flash and NOR (ARM-ADS)
  device: STM32F427ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: application +hex
  c flags: Optim=4
  c define: ST STM32F469xx USE_OS_SYSTICK USE_BPP=24
  c include: ../../touchgfx/framework/include;../../gui/include;../../target/include;../../platform/os;../../generated/fonts/include;../../generated/images/include;../../generated/texts/include;../../generated/gui_generated/include;../bsp/include;../bsp/include/platform/core/arm/cortex-m/CMSIS;../bsp/include/platform/hal/mcu/stm32f4cube;../bsp/include/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver;../bsp/include/platform/hal/mcu/stm32f4cube/CMSIS;../bsp/include;../bsp/include/bsp;../bsp/source/vendor/STM32469I-Discovery;../os/FreeRTOS7.6.0/Source/include;../os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F
  asm include: ../../platform/os
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ./Flash.sct
  group Startup
    ../bsp/source/platform/hal/mcu/stm32f4cube/Keil/: startup_stm32f469xx.s
    ../: main.cpp
  group TouchGFXHAL
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../bsp/source/platform/hal/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: OTM8009TouchController.cpp Buttons.cpp KeySampler.cpp
  group HAL
    ../bsp/source/platform/hal/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
    ../bsp/source/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_ltdc_ex.c
    ../bsp/source/vendor/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
    ../bsp/source/vendor/Components/ft6x06/: ft6x06.c
    ../bsp/source/vendor/Components/otm8009a/: otm8009a.c
  group OS
    ../os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/widgets/: accordionmenu.cpp buttonitem.cpp configbutton.cpp numericalwheelselector.cpp starmapwidget.cpp wheelselector.cpp
    ../../gui/src/alignscreen_screen/: alignscreenpresenter.cpp alignscreenview.cpp
    ../../gui/src/basescreen_screen/: basescreenpresenter.cpp basescreenview.cpp
    ../../gui/src/containers/: configpopup.cpp coordinatepopup.cpp joystick.cpp messagepopup.cpp
    ../../gui/src/dummyscreen_screen/: dummyscreenpresenter.cpp dummyscreenview.cpp
    ../../gui/src/common/: frontendapplication.cpp
    ../../gui/src/homescreen_screen/: homescreenpresenter.cpp homescreenview.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/mountscreen_screen/: mountscreenpresenter.cpp mountscreenview.cpp
    ../../gui/src/polaralignscreen_screen/: polaralignscreenpresenter.cpp polaralignscreenview.cpp
    ../../gui/src/settingscreen_screen/: settingscreenpresenter.cpp settingscreenview.cpp
    ../../gui/src/starmapscreen_screen/: starmapscreenpresenter.cpp starmapscreenview.cpp
    ../../gui/src/utilityscreen_screen/: utilityscreenpresenter.cpp utilityscreenview.cpp
  group generated
    ../../generated/images/src/: align.cpp back_arrow_48.cpp bitmapdatabase.cpp button1-pressed.cpp button1.cpp button2-pressed.cpp button2.cpp button3-pressed.cpp button3.cpp color_dial.cpp color_dial_red.cpp constell-bright.cpp constell-dark.cpp down_arrow_48.cpp eq_off.cpp eq_on.cpp goto.cpp home_button.cpp home_button2.cpp knob.cpp moon_small.cpp next_arrow_48.cpp polar.cpp slidersmall_round_back.cpp slidersmall_round_fill.cpp star1.cpp stars.cpp stop-pressed.cpp stop.cpp telescope.cpp track-bright.cpp track-dark.cpp up_arrow_48.cpp utility.cpp wrench.cpp
    ../../generated/gui_generated/src/alignscreen_screen/: alignscreenviewbase.cpp
    ../../generated/fonts/src/: applicationfontprovider.cpp font_dejavusans_bold_40_4bpp.cpp font_trebuc_16_4bpp.cpp font_trebuc_24_4bpp.cpp font_trebuc_32_4bpp.cpp font_trebucbd_40_4bpp.cpp fontgetters.cpp kerning_dejavusans_bold_40_4bpp.cpp kerning_trebuc_16_4bpp.cpp kerning_trebuc_24_4bpp.cpp kerning_trebuc_32_4bpp.cpp kerning_trebucbd_40_4bpp.cpp table_dejavusans_bold_40_4bpp.cpp table_trebuc_16_4bpp.cpp table_trebuc_24_4bpp.cpp table_trebuc_32_4bpp.cpp table_trebucbd_40_4bpp.cpp
    ../../generated/gui_generated/src/basescreen_screen/: basescreenviewbase.cpp
    ../../generated/gui_generated/src/containers/: configpopupbase.cpp coordinatepopupbase.cpp joystickbase.cpp messagepopupbase.cpp
    ../../generated/images/src/__designer/: dark_icons_down_arrow_48.cpp dark_icons_go_next_48.cpp dark_icons_refresh_48.cpp dark_icons_remove_48.cpp dark_icons_trash_48.cpp dark_icons_up_arrow_48.cpp dark_slider_horizontal_large_indicators_slider_round_nob.cpp
    ../../generated/gui_generated/src/dummyscreen_screen/: dummyscreenviewbase.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/gui_generated/src/homescreen_screen/: homescreenviewbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/mountscreen_screen/: mountscreenviewbase.cpp
    ../../generated/gui_generated/src/polaralignscreen_screen/: polaralignscreenviewbase.cpp
    ../../generated/gui_generated/src/settingscreen_screen/: settingscreenviewbase.cpp
    ../../generated/gui_generated/src/starmapscreen_screen/: starmapscreenviewbase.cpp
    ../../generated/gui_generated/src/utilityscreen_screen/: utilityscreenviewbase.cpp
