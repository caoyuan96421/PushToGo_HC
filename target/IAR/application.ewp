# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ST; STM32F469xx; USE_FLOATING_POINT; USE_OS_SYSTICK; USE_BPP=24
  ICCARM.CCIncludePath2: ..\..\generated\images\include; ..\..\generated\fonts\include; ..\..\generated\texts\include; ..\..\generated\gui_generated\include; ..\..\platform\os; ..\..\gui\include; ..\..\target\include; ..\..\touchgfx\framework\include; ..\bsp\include\platform\cortex-m; ..\bsp\include\platform\cortex-m\CMSIS; ..\bsp\include\platform\hal\mcu\stm32f4cube; ..\bsp\include\platform\hal\mcu\stm32f4cube\STM32F4xx_HAL_Driver; ..\bsp\include\platform\hal\mcu\stm32f4cube\CMSIS; ..\bsp\include; ..\bsp\include\bsp; ..\bsp\source\vendor\STM32469I-Discovery; ..\os\FreeRTOS7.6.0\Source\include; ..\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkExtraOptions: --redirect _ZN8touchgfx12TextProvider10initializeEPKt9__va_list=_ZN8touchgfx12TextProvider10initializeEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKc9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKc8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKt9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthLTREhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthLTREhPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthRTLEhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthRTLEhPKt8_VA_LIST
  ILINK.IlinkAdditionalLibs: ..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp Font_DejaVuSans_Bold_40_4bpp.cpp Font_trebuc_16_4bpp.cpp Font_trebuc_24_4bpp.cpp Font_trebuc_32_4bpp.cpp Font_trebucbd_40_4bpp.cpp FontGetters.cpp Kerning_DejaVuSans_Bold_40_4bpp.cpp Kerning_trebuc_16_4bpp.cpp Kerning_trebuc_24_4bpp.cpp Kerning_trebuc_32_4bpp.cpp Kerning_trebucbd_40_4bpp.cpp Table_DejaVuSans_Bold_40_4bpp.cpp Table_trebuc_16_4bpp.cpp Table_trebuc_24_4bpp.cpp Table_trebuc_32_4bpp.cpp Table_trebucbd_40_4bpp.cpp
  group Application/generated/gui_generated/alignscreen_screen
    ../../generated/gui_generated/src/alignscreen_screen/: AlignScreenViewBase.cpp
  group Application/generated/gui_generated/basescreen_screen
    ../../generated/gui_generated/src/basescreen_screen/: BaseScreenViewBase.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/containers
    ../../generated/gui_generated/src/containers/: ConfigPopupBase.cpp CoordinatePopupBase.cpp JoyStickBase.cpp
  group Application/generated/gui_generated/dummyscreen_screen
    ../../generated/gui_generated/src/dummyscreen_screen/: DummyScreenViewBase.cpp
  group Application/generated/gui_generated/homescreen_screen
    ../../generated/gui_generated/src/homescreen_screen/: HomeScreenViewBase.cpp
  group Application/generated/gui_generated/mountscreen_screen
    ../../generated/gui_generated/src/mountscreen_screen/: MountScreenViewBase.cpp
  group Application/generated/gui_generated/polaralignscreen_screen
    ../../generated/gui_generated/src/polaralignscreen_screen/: PolarAlignScreenViewBase.cpp
  group Application/generated/gui_generated/settingscreen_screen
    ../../generated/gui_generated/src/settingscreen_screen/: SettingScreenViewBase.cpp
  group Application/generated/gui_generated/starmapscreen_screen
    ../../generated/gui_generated/src/starmapscreen_screen/: StarMapScreenViewBase.cpp
  group Application/generated/gui_generated/utilityscreen_screen
    ../../generated/gui_generated/src/utilityscreen_screen/: UtilityScreenViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: align.cpp Back_arrow_48.cpp BitmapDatabase.cpp button1-pressed.cpp button1.cpp button2-pressed.cpp button2.cpp button3-pressed.cpp button3.cpp Down_arrow_48.cpp home_button.cpp home_button2.cpp knob.cpp moon_small.cpp Next_arrow_48.cpp polar.cpp Slidersmall_Round_back.cpp Slidersmall_Round_fill.cpp star1.cpp stars.cpp stop-pressed.cpp stop.cpp telescope.cpp Up_arrow_48.cpp utility.cpp wrench.cpp
  group Application/generated/images/__designer
    ../../generated/images/src/__designer/: blue_togglebars_toggle_re_small_button_off.cpp blue_togglebars_toggle_re_small_button_on.cpp dark_icons_down_arrow_48.cpp dark_icons_go_next_48.cpp dark_icons_refresh_48.cpp dark_icons_remove_48.cpp dark_icons_trash_48.cpp dark_icons_up_arrow_48.cpp dark_slider_horizontal_large_indicators_slider_round_nob.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/alignscreen_screen
    ../../gui/src/alignscreen_screen/: AlignScreenPresenter.cpp AlignScreenView.cpp
  group Application/gui/basescreen_screen
    ../../gui/src/basescreen_screen/: BaseScreenPresenter.cpp BaseScreenView.cpp
  group Application/gui/common
    ../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/containers
    ../../gui/src/containers/: ConfigPopup.cpp CoordinatePopup.cpp JoyStick.cpp
  group Application/gui/dummyscreen_screen
    ../../gui/src/dummyscreen_screen/: DummyScreenPresenter.cpp DummyScreenView.cpp
  group Application/gui/homescreen_screen
    ../../gui/src/homescreen_screen/: HomeScreenPresenter.cpp HomeScreenView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/mountscreen_screen
    ../../gui/src/mountscreen_screen/: MountScreenPresenter.cpp MountScreenView.cpp
  group Application/gui/polaralignscreen_screen
    ../../gui/src/polaralignscreen_screen/: PolarAlignScreenPresenter.cpp PolarAlignScreenView.cpp
  group Application/gui/settingscreen_screen
    ../../gui/src/settingscreen_screen/: SettingScreenPresenter.cpp SettingScreenView.cpp
  group Application/gui/starmapscreen_screen
    ../../gui/src/starmapscreen_screen/: StarMapScreenPresenter.cpp StarMapScreenView.cpp
  group Application/gui/utilityscreen_screen
    ../../gui/src/utilityscreen_screen/: UtilityScreenPresenter.cpp UtilityScreenView.cpp
  group Application/gui/widgets
    ../../gui/src/widgets/: AccordionMenu.cpp ButtonItem.cpp ConfigButton.cpp NumericalWheelSelector.cpp StarMapWidget.cpp WheelSelector.cpp
  group Application/main
    ../: main.cpp
  group CubeF4/Board
    ../bsp/source/vendor/Components/ft6x06/: ft6x06.c
    ../bsp/source/vendor/Components/otm8009a/: otm8009a.c
    ../bsp/source/vendor/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
  group CubeF4/MCU
    ../bsp/source/platform/hal/mcu/stm32f4cube/IAR/: startup_stm32f469xx.s
    ../bsp/source/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
    ../bsp/source/platform/hal/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
  group OS
    ../os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFXPort/Board
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: Buttons.cpp KeySampler.cpp OTM8009TouchController.cpp
  group TouchGFXPort/MCU
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../bsp/source/platform/hal/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp
